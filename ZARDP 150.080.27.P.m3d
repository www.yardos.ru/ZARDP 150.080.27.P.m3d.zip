# KOMPAS-3D part (ZARDP 150.080.27.P.m3d)

Model tree:
1. Булева операция:1
